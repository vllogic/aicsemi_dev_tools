# IAR project flashloader.ewp, settings and files
configuration aic8800mbw (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration aic8800mc (ARM, debug)
  as the first configuration, except:
  OBJCOPY.OOCOutputFile: flashloader.srec
  group (top)
    ./: flash_config.h flash_loader.c flash_loader.h flash_loader_asm.s flash_loader_extra.h flash_loader_ram_aic8800mbw.c flash_loader_ram_aic8800mc.c
